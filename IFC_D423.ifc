Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2022-06-22T19:05:30
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20211019_1515(x64) - Exporter 20.2.60.15 - Alternate UI 20.2.60.15
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jun 22 19:05:30 2022 * Host: DESKTOP-KN3O7NT * Database: C:\Users\SARAHS~1\AppData\Local\Temp\e8e4c436-fe44-4f00-813f-5fc7136bb8be\dc22f7e7-d2dd-4aeb-9e6e-43dcb0165611\ifc * Database version: 5507 * Database creation date: Wed Jun 22 19:05:20 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jun 22 19:05:21 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jun 22 19:05:21 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:Circle Head - Project Datum, Level 0
LongName: Level 0; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 0
Pset_ProductRequirements - Name: Level 0; Category: Levels

# IfcDistributionPort (12)
Description: Flow
Name | FlowDirection
2 x Port_321644 | SOURCEANDSINK
2 x Port_321644 | SOURCE
2 x Port_328171 | SOURCEANDSINK
2 x Port_328171 | SOURCE
2 x Port_328197 | SOURCEANDSINK
2 x Port_328197 | SOURCE

# IfcFlowController: Shower Kit in Brushed Stainless Steel, DBLTD_Duten_ShwrFttngsPckg_D423:Shower Kit in Brushed Stainless Steel:328171
In: Level 0
Type - PredefinedType: MIXING; Material: Duten_Metal_BrushedStainlessSteel
Type - Pset_ValveTypeCommon - FlowCoefficient: 0; ValvePattern: n/a; ValveOperation: Dual control; ValveMechanism: Thermostatic; TestPressure: 0 Pa; WorkingPressure: 0 Pa; CloseOffRating: 0 Pa
Type - Pset_ValveTypeFaucet - Finish: Available in brushed or polished stainless steel and matte black
Type - Pset_ValveTypeMixing - MixerControl: n/a
Pset_DistributionFlowElementCommon - Reference: n/a; sets with these values: 2
Pset_ElementShading - Color: Defined by material specified
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Pset_ManufacturerTypeInformation - ModelReference: Shower Kit in Brushed Stainless Steel; Manufacturer: Duten
Pset_ProductRequirements - Name: ShowerFittingsPackage_D423_Duten; Category: Plumbing Fixtures

# IfcFlowController: Shower Kit in Matte Black, DBLTD_Duten_ShwrFttngsPckg_D423:Shower Kit in Matte Black:328197
In: Level 0
Type - PredefinedType: MIXING; Material: Duten_Metal_MatteBlack
Type - Pset_ValveTypeCommon - FlowCoefficient: 0; ValvePattern: n/a; ValveOperation: Dual control; ValveMechanism: Thermostatic; TestPressure: 0 Pa; WorkingPressure: 0 Pa; CloseOffRating: 0 Pa
Type - Pset_ValveTypeFaucet - Finish: Available in brushed or polished stainless steel and matte black
Type - Pset_ValveTypeMixing - MixerControl: n/a
Pset_DistributionFlowElementCommon - Reference: n/a; sets with these values: 2
Pset_ElementShading - Color: Defined by material specified
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Pset_ManufacturerTypeInformation - ModelReference: Shower Kit in Matte Black; Manufacturer: Duten
Pset_ProductRequirements - Name: ShowerFittingsPackage_D423_Duten; Category: Plumbing Fixtures

# IfcFlowController: Shower Kit in Polished Stainless Steel, DBLTD_Duten_ShwrFttngsPckg_D423:Shower Kit in Polished Stainless Steel:321644
In: Level 0
Type - PredefinedType: MIXING; Material: Duten_Metal_PolishedStainlessSteel
Type - Pset_ValveTypeCommon - ValvePattern: n/a; ValveOperation: Dual control; ValveMechanism: Thermostatic; TestPressure: 0 Pa; WorkingPressure: 0 Pa; FlowCoefficient: 0; CloseOffRating: 0 Pa
Type - Pset_ValveTypeFaucet - Finish: Available in brushed or polished stainless steel and matte black
Type - Pset_ValveTypeMixing - MixerControl: n/a
Pset_DistributionFlowElementCommon - Reference: n/a; sets with these values: 2
Pset_ElementShading - Color: Defined by material specified
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Pset_ManufacturerTypeInformation - ModelReference: Shower Kit in Polished Stainless Steel; Manufacturer: Duten
Pset_ProductRequirements - Name: ShowerFittingsPackage_D423_Duten; Category: Plumbing Fixtures
